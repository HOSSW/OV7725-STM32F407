# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HARDWARE\LCD;..\HARDWARE\SPI;..\HARDWARE\DCMI;..\HARDWARE\OV7670;..\HARDWARE\SRAM;..\HARDWARE\TIMER;..\HARDWARE\LED;..\HARDWARE\EasyTracered;..\HARDWARE\PWM;..\HARDWARE\KEY;..\HARDWARE\pid
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_dma.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_exti.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group README
    ../: readme.txt
  group HARDWARE
    ../HARDWARE/LCD/: lcd.c GUI.c
    ../HARDWARE/SPI/: SPI.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/OV7670/: ov7670.c sccb.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/EasyTracered/: EasyTracered.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/pid/: pid.c
